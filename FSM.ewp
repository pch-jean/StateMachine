# IAR project FSM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group StateMachine
    ./: Allocator.cpp Allocator.h CentrifugeTest.cpp CentrifugeTest.h Fault.cpp Fault.h Motor.cpp Motor.h MotorNM.cpp MotorNM.h Player.cpp Player.h SelfTest.cpp Selftest.h StateMachine.cpp StateMachine.h
